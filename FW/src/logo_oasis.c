#include "logo_oasis.h"

// Composited from Lopaka Vector2 + paint layers (54x18, MSB-first rows).
static const uint8_t k_oasis_logo[] = {
    0x3f, 0x00, 0xe0, 0x3f, 0x83, 0x07, 0xf0, 0x7f, 0x80, 0xe0, 0x7f, 0xc3, 0x0f, 0xf8,
    0xe1, 0xc0, 0xe0, 0xf0, 0xe3, 0x1c, 0x38, 0xc0, 0xc0, 0xe0, 0xe0, 0xe3, 0x1c, 0x1c,
    0xc7, 0xc1, 0xf0, 0xe0, 0x63, 0x1c, 0x1c, 0xc3, 0xc1, 0xf0, 0x60, 0x03, 0x1c, 0x00,
    0xc3, 0xc1, 0xb0, 0x70, 0x03, 0x1e, 0x00, 0xc1, 0xc3, 0xb0, 0x7c, 0x03, 0x0f, 0x00,
    0xcc, 0xc3, 0xb8, 0x3f, 0x03, 0x07, 0xe0, 0xcc, 0xc3, 0xb8, 0x0f, 0xc3, 0x01, 0xf0,
    0xe0, 0xc7, 0x18, 0x01, 0xe3, 0x00, 0x78, 0xf0, 0xc7, 0x1c, 0x00, 0xf3, 0x00, 0x1c,
    0xf0, 0xc7, 0xfc, 0x60, 0x73, 0x18, 0x1c, 0xf8, 0xc7, 0xfc, 0xe0, 0x73, 0x18, 0x1c,
    0xc0, 0xce, 0x0e, 0xe0, 0x73, 0x1c, 0x1c, 0xe1, 0xce, 0x0e, 0x70, 0xe3, 0x1c, 0x38,
    0x7f, 0x8e, 0x0e, 0x7f, 0xc3, 0x0f, 0xf8, 0x3f, 0x0e, 0x0e, 0x3f, 0x83, 0x07, 0xf0,
};

void logo_oasis_draw(uint8_t *fb, int fb_w, int fb_h, int x, int y) {
    if (!fb) {
        return;
    }

    for (int row = 0; row < OASIS_LOGO_H; ++row) {
        const int py = y + row;
        if (py < 0 || py >= fb_h) {
            continue;
        }

        const uint8_t *src = &k_oasis_logo[row * OASIS_LOGO_ROW_BYTES];
        for (int bx = 0; bx < OASIS_LOGO_ROW_BYTES; ++bx) {
            const uint8_t byte = src[bx];
            for (int bit = 0; bit < 8; ++bit) {
                const int px = x + bx * 8 + bit;
                if (px < 0 || px >= fb_w || px >= x + OASIS_LOGO_W) {
                    continue;
                }
                if (byte & (0x80u >> bit)) {
                    const int idx = px + (py / 8) * fb_w;
                    fb[idx] |= (uint8_t)(1u << (py & 7));
                }
            }
        }
    }
}
