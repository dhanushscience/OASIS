#include "font5x7.h"

#include <stdbool.h>
#include <string.h>

static void set_pixel(uint8_t *fb, int w, int h, int x, int y, bool on) {
    if (x < 0 || y < 0 || x >= w || y >= h) {
        return;
    }
    const int byte = x + (y / 8) * w;
    const uint8_t mask = 1u << (y & 7);
    if (on) {
        fb[byte] |= mask;
    } else {
        fb[byte] &= (uint8_t)~mask;
    }
}

// Minimal 5x7 glyphs for A-Z, 0-9, space, %, >
static int glyph_index(char c) {
    if (c == ' ') return 0;
    if (c >= '0' && c <= '9') return 1 + (c - '0');
    if (c >= 'A' && c <= 'Z') return 11 + (c - 'A');
    if (c == '%') return 37;
    if (c == '>') return 38;
    return 39; // ?
}

static const uint8_t kGlyphs[][5] = {
    {0x00,0x00,0x00,0x00,0x00}, // space
    {0x3E,0x51,0x49,0x45,0x3E}, // 0
    {0x00,0x42,0x7F,0x40,0x00}, // 1
    {0x42,0x61,0x51,0x49,0x46}, // 2
    {0x21,0x41,0x45,0x4B,0x31}, // 3
    {0x18,0x14,0x12,0x7F,0x10}, // 4
    {0x27,0x45,0x45,0x45,0x39}, // 5
    {0x3C,0x4A,0x49,0x49,0x30}, // 6
    {0x01,0x71,0x09,0x05,0x03}, // 7
    {0x36,0x49,0x49,0x49,0x36}, // 8
    {0x06,0x49,0x49,0x29,0x1E}, // 9
    {0x7C,0x12,0x11,0x12,0x7C}, // A
    {0x7F,0x49,0x49,0x49,0x36}, // B
    {0x3E,0x41,0x41,0x41,0x22}, // C
    {0x7F,0x41,0x41,0x22,0x1C}, // D
    {0x7F,0x49,0x49,0x49,0x41}, // E
    {0x7F,0x09,0x09,0x09,0x01}, // F
    {0x3E,0x41,0x49,0x49,0x7A}, // G
    {0x7F,0x08,0x08,0x08,0x7F}, // H
    {0x00,0x41,0x7F,0x41,0x00}, // I
    {0x20,0x40,0x41,0x3F,0x01}, // J
    {0x7F,0x08,0x14,0x22,0x41}, // K
    {0x7F,0x40,0x40,0x40,0x40}, // L
    {0x7F,0x02,0x0C,0x02,0x7F}, // M
    {0x7F,0x04,0x08,0x10,0x7F}, // N
    {0x3E,0x41,0x41,0x41,0x3E}, // O
    {0x7F,0x09,0x09,0x09,0x06}, // P
    {0x3E,0x41,0x51,0x21,0x5E}, // Q
    {0x7F,0x09,0x19,0x29,0x46}, // R
    {0x46,0x49,0x49,0x49,0x31}, // S
    {0x01,0x01,0x7F,0x01,0x01}, // T
    {0x3F,0x40,0x40,0x40,0x3F}, // U
    {0x1F,0x20,0x40,0x20,0x1F}, // V
    {0x3F,0x40,0x38,0x40,0x3F}, // W
    {0x63,0x14,0x08,0x14,0x63}, // X
    {0x07,0x08,0x70,0x08,0x07}, // Y
    {0x61,0x51,0x49,0x45,0x43}, // Z
    {0x23,0x13,0x08,0x64,0x62}, // %
    {0x08,0x14,0x22,0x41,0x00}, // >
    {0x41,0x36,0x08,0x00,0x00}, // ?
};

int font5x7_char_width(void) { return 6; }
int font5x7_char_height(void) { return 8; }

int font5x7_string_width(const char *s) {
    int w = 0;
    while (s && *s) {
        w += 6;
        ++s;
    }
    return w > 0 ? w - 1 : 0;
}

void font5x7_draw_char(uint8_t *fb, int w, int h, int x, int y, char c) {
    if (c >= 'a' && c <= 'z') {
        c = (char)(c - 'a' + 'A');
    }
    const int gi = glyph_index(c);
    const uint8_t *glyph = kGlyphs[gi];
    for (int col = 0; col < 5; ++col) {
        const uint8_t line = glyph[col];
        for (int row = 0; row < 7; ++row) {
            if (line & (1 << row)) {
                set_pixel(fb, w, h, x + col, y + row, true);
            }
        }
    }
}
